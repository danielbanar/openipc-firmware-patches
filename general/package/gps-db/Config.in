## general/package/wireguard-db/Config.in
```kconfig
config BR2_PACKAGE_WIREGUARD_DB
	bool "wireguard-db"
	select BR2_PACKAGE_WIREGUARD_LINUX_COMPAT
	select BR2_PACKAGE_WIREGUARD_TOOLS
```
